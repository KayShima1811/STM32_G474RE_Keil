# Keil uVision project Blinky_Led.uvprojx, settings and files
target Blinky (6190000::V6.19::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky_Led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ./: main.c
  group Inc
    ./: main.h stm32g4_configlib.h stm32g4_defvar.h stm32g4_flash.h stm32g4_gpio.h stm32g4_pwr.h stm32g4_rcc.h stm32g4_timer.h
  group Src
    ./: stm32g4_delay.c stm32g4_gpio.c stm32g4_rcc.c stm32g4_timer.c
  group Startup
    ./: startup_stm32g474xx.s system_stm32g4xx.c
software components: CMSIS:CORE 5.6.0
